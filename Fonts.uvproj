# Keil uVision project Fonts.uvproj, settings and files
target Fonts (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Fonts (library)
  c flags: Optim=1
  c include: .\emwin\v5\GUI;.\emwin\Porting
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Fonts
    ./emwin/Fonts/C_File_Output/: Font_AR_Mingti_Medium_B523.c Font_Arial19.c Font_HG_GB_Gothic23.c Font_HGGothicB19.c Font_HGPGothicB19.c
