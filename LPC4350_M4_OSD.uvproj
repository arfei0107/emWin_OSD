# Keil uVision project LPC4350_M4_OSD.uvproj, settings and files
target LPC4350_M4_OSD_SPIFI (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LPC4350_M4_OSD +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 oTime=1
  c define: CORE_M4 LPC43XX AOCI_BOARD EXT_DYN_MEM CLKOUT_HALF AOCI_LCD
  c include: .\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;.\lpc_core\lpc_chip\chip_common;.\lpc_core\lpc_chip\chip_18xx_43xx;.\lpc_core\lpc_board\board_common;.\CMSIS\CMSIS\Include;.\lpc_core\lpc_board\boards_43xx\hitex_eva_4350;.\freertos\freertos\Source\include;.\freertos\freertos\Source\portable\RVDS\ARM_CM4F;.\freertos;.\emwin\emWin_header;.\emwin\emWin_Config;.\Drivers;.\Application;.\misc;.\emwin\Custom_Widget;.\UI\ImageAdjust;.\UI\InputSignal;.\UI\Installation;.\UI\DisplaySetup;.\UI\Function;.\UI\Information;.\UI
  asm define: CORE_M4
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x800000
  memory RVCT6: RAM 0x28000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Linker-script\LPC4350_CodeIRAM_FontSDRAM.sct
  group Startup
    ./Startup/: keil_freertos_startup_lpc18xx43xx.s sysinit.c
  group LPC_chip
    ./lpc_core/lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c gpiogroup_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pinint_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c scu_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
  group LPC_chip_common
    ./lpc_core/lpc_chip/chip_common/: fpu_init.c ring_buffer.c
  group LPC_board
    ./lpc_core/lpc_board/boards_43xx/hitex_eva_4350/: board.c board_sysinit.c
    ./lpc_core/lpc_board/board_common/: lpc_phy_dp83848.c mem_tests.c
  group FreeRTOS
    ./freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ./freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ./freertos/freertos/Source/portable/MemMang/: heap_3.c
    ./freertos/: FreeRTOSConfig.h
  group emWin
    ./emwin/emWin_Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ./emwin/emWin_library/uVision_4/: emWin_M4fp.lib
  group Application
    ./: Main.c
    ./Application/: GUI_User_Task.c
  group Drivers
    ./Drivers/: emc_LPC18xx_43xx.c scu_LPC18xx_43xx.c
  group Fonts
    ./emwin/Fonts/Build-output/: Fonts.lib
  group misc
    ./misc/: ustdlib.c
  group Custom_Widget
    ./emwin/Custom_Widget/: xMultiPage.c xButton.c xDIALOG.c xDROPDOWN.c xSLIDER.c xMoveBtn.c xKBbtn.c xEDIT.c xIconSelBtn.c
  group BMPs
    ./BMPs/: arrow_w11_h11_n.c base_44_26.c base_190_26.c base_pshift_w260_h78.c base_slider_off.c base_slider_on.c base_slider_on_blue.c base_slider_on_blue_pixel_v.c base_slider_on_green.c base_slider_on_red.c base_slider_on_red_pixel_v.c base_value_w100_h26.c bt_layer1_f.c bt_layer1_h.c Bt_w36_h36_f.c Bt_w36_h36_n.c bt_w54_h30_f.c bt_w120_h30_n.c bt_w124_h26_h.c bt_w124_h26_n.c bt_w124_h36_f.c bt_w124_h36_h.c bt_w124_h36_h_1.c bt_w134_h30_f.c bt_w138_h26_f_1.c bt_w138_h36_f.c bt_w144_h26_n.c bt_w158_h26_f.c bt_w160_h30_f_1.c Bt_w168_h36_f.c Bt_w168_h36_n.c bt_w174_h30_f.c bt_w190_h26_f_1.c bt_w190_h26_n_a.c Bt_w212_h36_n.c bt_w220_h36_f_1.c bt_w220_h36_h_1.c bt_w456_h36_f.c bt_w456_h36_f_u.c bt_w456_h36_h.c bt_w456_h36_n_a.c bt_w470_h36_f.c color_BLUE.c color_CYAN.c color_GREEN.c color_MAGENTA.c color_ORANGE.c color_RED.c color_YELLOW.c gamma_pointer.c guide_a1.c guide_a2.c guide_b1.c guide_b123.c guide_back.c guide_c1.c guide_colorpfile.c guide_colortemp.c guide_d1.c guide_d2.c guide_d3.c guide_gamma.c guide_menu.c guide_picadj.c guide_test.c icon_1_1f.c icon_1_1h.c icon_1_1n.c icon_1_2f.c icon_1_2h.c icon_1_2n.c icon_1_3f.c icon_1_3h.c icon_1_3n.c icon_1_4f.c icon_1_4h.c icon_1_4n.c icon_1_5f.c icon_1_5h.c icon_1_5n.c icon_1_6f.c icon_1_6h.c icon_1_6n.c icon_keystone_d.c icon_keystone_l.c icon_keystone_r.c icon_keystone_u.c icon_position1.c icon_position3.c icon_position5.c icon_position7.c icon_position9.c icon_shutdown.c image_gy_scale.c mark_arrow_bl_l_8_14.c mark_arrow_bl_r_8_14.c mark_arrow_gr_8_14.c mark_arrow_key_g_d.c mark_arrow_key_g_l.c mark_arrow_key_g_r.c mark_arrow_key_g_u.c mark_arrow_key_w_d.c mark_arrow_key_w_l.c mark_arrow_key_w_r.c mark_arrow_key_w_u.c mark_arrow_yellow_d.c mark_arrow_yellow_l.c mark_arrow_yellow_mini_d.c mark_arrow_yellow_mini_u.c mark_arrow_yellow_r.c mark_arrow_yellow_u.c mark_check.c mark_left_8_16.c mark_slider_off.c mark_slider_on.c mark_slider_on_2.c pointer.c test_after.c test_after_w144_h26.c test_before.c test_before_w144_h26.c bt_w190_h26_a.c bt_w470_h36_n.c bt_w470_h36_h.c
  group UI
    ./UI/: UI_Entry.c
    ./UI/ImageAdjust/: ImageAdjustWin.c GammaFormula.c
    ./UI/InputSignal/: InputSignalWin.c
    ./UI/Installation/: InstallationlWin.c
    ./UI/DisplaySetup/: DisplaySetuplWin.c
    ./UI/Function/: FunctionWin.c
    ./UI/Information/: InformationWin.c
